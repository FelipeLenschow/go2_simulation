Commit message: Add go2 real launch

File: go2_description/urdf/torso.xacro (robot description, xacro)
@@ -6,5 +6,5 @@
         <parent link="world"/>
         <child link="base"/>
-        <origin xyz="0 0 1"/>
+        <origin xyz="0 0 0"/>
       </joint>
     <!-- World frame -->
